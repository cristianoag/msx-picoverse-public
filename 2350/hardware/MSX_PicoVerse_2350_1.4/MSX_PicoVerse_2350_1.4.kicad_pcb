# Repository cristianoag/msx-picoverse-public

File README.md (part):

# The PicoVerse for MSX

**The MSX experience driven by the Raspberry Pi Pico family of microcontrollers.**

The PicoVerse project is a community-driven effort to build versatile MSX cartridges powered by Raspberry Pi Pico development boards. The project pairs accessible hardware designs with ready-to-flash firmware so MSX lovers can jump straight into loading games, tools, and Nextor without having to compile sources.

| Cartridge Label - 2040 Variant | Cartridge Label - 2350 Variant |
|---------|---------|
| |  |

PicoVerse is designed as an open-source, independent, and documented MSX cartridge platform. Compatibility with other projects is neither a goal nor guaranteed (I tested some without much success); running third‑party software on PicoVerse hardware, or PicoVerse firmware on other boards, is at your own risk. The source and manufacturing files are openly available so you can learn, experiment, and build on them for the MSX community, subject to the project license.

If you find any issues, have questions, or want to contribute, please open an issue or reach out via the contact information in the repository.

## Project Highlights

### Core Platform (PicoVerse 2040 & 2350)
- **Instant Single-ROM & Multi-ROM Cartridges**: Boot a single title directly with `LoadROM` or browse a multi-game menu with `MultiROM` (up to 16 MB of flash), backed by heuristic + SHA-1 database mapper auto-detection (`Plain 16/32/48/64`, `Konami`, `Konami SCC`, `ASCII 8/16/16X`, `NEO-8/16`, and `Manbow2`).
- **Nextor + Sunrise IDE Mass Storage**: Ready-to-use Nextor 2.1.4 (and released Nextor 3.0.0) builds via Sunrise IDE emulation over USB or microSD, available standalone or paired with expanded Memory Mapper RAM (`192 KB` on 2040, `1 MB` on 2350).
- **USB Floppy Drive (FDD) & `.DSK` Disk Image Interface**: Standalone MSX-DOS 1 disk ROM (`msxusbfdd.exe`, available for both PicoVerse 2040 and PicoVerse 2350) supporting real 720 KB / 1.44 MB USB floppy drives (**only through an externally powered USB hub — never connect a floppy drive directly to the cartridge**) and `.DSK` disk images on FAT12/FAT16/FAT32 USB flash drives, with an interactive boot menu and `CALL USB*` BASIC commands ([2040 guide](/docs/msx-picoverse-2040-msxusbfdd.md), [2350 guide](/docs/msx-picoverse-2350-msxusbfdd.md)).
- **Zero-Compile UF2 Builders & openMSX Preview**: PC tools generate drag-and-drop `.uf2` firmware images in seconds, and the included openMSX emulated cartridges ([2040 MultiROM](/docs/msx-picoverse-2040-openmsx.md), [2350 Explorer](/docs/msx-picoverse-2350-openmsx.md)) let you test your `.uf2` images on a PC before flashing.
- **Open Hardware**: Interactive BOMs, and production-ready Gerbers for both cartridge variants.

### PicoVerse 2040 Highlights (RP2040)
- **ROM, MultiROM & Nextor USB Storage**: Run ROMs and MultiROM menus from flash, or boot Nextor from a USB flash drive (standalone or with a `192 KB` Memory Mapper).
- **USB Floppy Drive (FDD) & `.DSK` Disk Image Interface**: Standalone MSX-DOS 1 disk ROM (`msxusbfdd.exe`) supporting real 720 KB / 1.44 MB USB floppy drives (only through powered USB hubs) and `.DSK` disk images on FAT12/FAT16/FAT32 USB flash drives, with an interactive boot menu and `CALL USB*` BASIC commands ([guide](/docs/msx-picoverse-2040-msxusbfdd.md)).
- **USB Keyboard & USB Joystick Adapters**: Use a standard USB keyboard or up to two USB gamepads (HID, Xbox 360, Xbox One, Xbox Series X|S) as native MSX input devices via the cartridge slot.
- **MSX-MIDI & MIDI-PAC**: Use a USB-MIDI cable as a standard MSX-MIDI interface, or passively convert live MSX PSG music and sound effects into Roland SC-55–optimized General MIDI (`MIDI-PAC`).

### PicoVerse 2350 Highlights (RP2350 + PSRAM + microSD + I2S DAC + WiFi)
- **All-in-One Explorer Environment**: Unified browser for flash ROMs, microSD ROMs, embedded Sunrise Nextor entries, and `.DSK` floppy images (including multi-disk games with number-key disk swapping). Includes an MP3/WAV player, `WAVEGAME` CD-quality WAV streaming, on-device file management (search, copy to flash, rename, delete, partition cycling), and per-ROM 50/60 Hz & CPU speed settings.
- **PicoAmp by [@Jzzy-dev](https://github.com/Jzzy-dev)**: Dedicated third-party PicoVerse 2350 firmware with an MSX2 player, spectrum analyser, internet radio, equalizer, and more. [Download the UF2](/firmware/third-party/2350/picoamp_by_Jzzy_v1.0.uf2).
- **Built-In Sound Cartridges & Per-ROM Audio**: Per-ROM audio profiles for `SCC/SCC+`, `Dual PSG`, `MSX-MUSIC (YM2413 / FM-PAC)`, `Yamaha SFG01/SFG05 (YM2151)`, and primary PSG DAC mirroring through the 16-bit stereo I2S DAC — plus standalone **MoonSound / OPL4 (`YMF278B` + 2 MB Wave ROM + 2 MB Sample RAM)**, **MSX-AUDIO (`Y8950` + 256 KB ADPCM RAM)**, **Yamanooto** (8 MB flash with runtime SCC/FM/PSG auto-switching), and full **Carnivore2** emulation cartridge firmwares.
- **PSRAM Expansion Modes**: `1 MB` Memory Mapper, `1 MB` Memory Mapper + `1 MB` MegaRAM (128 × 8 KB banks in a dedicated subslot), and Carnivore2-compatible RAM-mode loading (`SROM.COM /D15`).
- **Full RBSC Carnivore2 Emulation (experimental)**: A dedicated firmware (`carnivore2.exe`) that turns the PicoVerse 2350 into a software-compatible Carnivore2: 8 MB FlashROM (RP2350 flash, with write-back), 1 MB Memory Mapper and 1 MB MegaRAM/shadow RAM in PSRAM, the Carnivore2 configuration registers and bank windows, IDE/Nextor from the microSD card, SCC/SCC+, FM-PAC, PSG and the configuration EEPROM. The original Carnivore2 boot menu and utilities (C2MAN, C2RAMLDR, C2BACKUP, ...) run unmodified ([guide](/docs/msx-picoverse-2350-carnivore2.md)).
- **USB Floppy Drive (FDD) & `.DSK` Disk Image Interface**: Standalone MSX-DOS 1 disk ROM (`msxusbfdd.exe`) supporting real 720 KB / 1.44 MB USB floppy drives (only through powered USB hubs) and `.DSK` disk images on FAT12/FAT16/FAT32 USB flash drives, with an interactive boot menu and `CALL USB*` BASIC commands ([guide](/docs/msx-picoverse-2350-msxusbfdd.md)).
- **ESP-01 WiFi & File Hunter Browser**: Browse and download ROMs and `.DSK` disk images over WiFi directly to the microSD card from the integrated File Hunter catalog, or enable ESP8266 WiFi in Sunrise IDE LoadROM/MultiROM builds.

## Documentation

**LoadROM Guides:** Use the LoadROM tool to create a UF2 image that boots directly into a single ROM, skipping the menu. Mapper type is auto-detected with filename tag overrides, and the tool reports the detected configuration before flashing.
- [MSX PicoVerse 2040 LoadROM Tool Manual (English)](/docs/msx-picoverse-2040-loadrom-tool-manual.en-us.md) 
- [MSX PicoVerse 2350 LoadROM Tool Manual (English)](/docs/msx-picoverse-2350-loadrom-tool-manual.en-us.md) 
  
**MultiROM Guides:** Use the MultiROM tool to create a UF2 image that allows selecting from multiple ROMs at boot. Mapper type is auto-detected with filename tag overrides, and the tool reports the detected configuration before flashing.
- [PicoVerse 2040 MultiROM Guide Manual (English)](/docs/msx-picoverse-2040-multirom-tool-manual.en-us.md)
- [PicoVerse 2350 MultiROM Tool Manual (English)](/docs/msx-picoverse-2350-multirom-tool-manual.en-us.md)

**openMSX Emulated Cartridge:** Try a PicoVerse 2040 MultiROM or PicoVerse 2350 Explorer UF2 in the openMSX emulator before flashing it. A Tcl script and an openMSX extension turn the `.uf2` into an emulated PicoVerse cartridge: the MSX boots the real menu, starts each entry with the matching openMSX hardware, and runs the Nextor Sunrise IDE entries with a hard disk image as the USB drive or microSD card. The Explorer add-on also uses a PC folder as the microSD card.
- [MSX PicoVerse 2040 — MultiROM in openMSX (English)](/docs/msx-picoverse-2040-openmsx.md)
- [MSX PicoVerse 2350 — Explorer in openMSX (English)](/docs/msx-picoverse-2350-openmsx.md)

**Explorer Guides:** Use the Explorer tool to manage flash, embedded Sunrise Nextor, and microSD ROMs, boot 360 KB/720 KB `.DSK` disk images (and multi-disk games joined into one `.DSK`, swapped with the number keys) from the microSD card, cycle supported microSD partitions, delete selected SD files or flash entries, copy microSD ROMs to flash, rename ROMs and disk images, play MP3/WAV files from the microSD card, browse File Hunter over ESP-01 WiFi, select ROM audio/PSG options, and search for titles on the device.
- [MSX PicoVerse 2350 Explorer Tool Manual (English)](/docs/msx-picoverse-2350-explorer-tool-manual.en-us.md)

**Yamanooto Guides:** Use the Yamanooto tool to create a UF2 that emulates a Yamanooto flash cartridge (Konami-SCC compatible, SCC/SCC+, dual PSG, primary PSG mirror, and MSX-MUSIC/FM-PAC) from a single ROM image, with the firmware choosing SCC/FM/PSG automatically at runtime.
- [MSX PicoVerse 2350 Yamanooto Tool Manual (English)](/docs/msx-picoverse-2350-yamanooto-tool-manual.en-us.md)

**Carnivore2 Guide:** Use the Carnivore2 tool to create a UF2 that turns the PicoVerse 2350 into a software-compatible RBSC Carnivore2 (1 MB memory mapper, MegaRAM/shadow RAM, 8 MB FlashROM, IDE/Nextor from microSD, SCC/SCC+, FM-PAC, PSG and the Carnivore2 configuration registers), so the original Carnivore2 boot menu and utilities run unmodified.
- [MSX PicoVerse 2350 Carnivore2 Implementation and Tool Guide (English)](/docs/msx-picoverse-2350-carnivore2.md)

**USB FDD & `.DSK` Guides:** Use the `msxusbfdd` tool to create a UF2 that turns the PicoVerse 2040 or PicoVerse 2350 into a standalone MSX-DOS 1 disk interface supporting both real USB floppy drives (720 KB and 1.44 MB, **connected exclusively via an externally powered USB hub**) and `.DSK` disk images on FAT12/FAT16/FAT32 USB flash drives, with an interactive boot menu and `CALL USB*` BASIC commands.
> **⚠️ IMPORTANT — DO NOT CONNECT A USB FLOPPY DRIVE DIRECTLY TO THE CARTRIDGE USB-C PORT:** Unlike the MSX-USB / RookieDrive, the PicoVerse cartridge cannot supply the current required to spin and step USB floppy drives. Connecting a USB FDD directly to the PicoVerse USB-C port can damage the cartridge. **Always connect USB floppy drives through an externally powered (5V) USB hub.**
- [MSX PicoVerse 2040 USB FDD Guide (English)](/docs/msx-picoverse-2040-msxusbfdd.md)
- [MSX PicoVerse 2350 USB FDD Guide (English)](/docs/msx-picoverse-2350-msxusbfdd.md)

**Reference Material**

*PicoVerse 2040 Reference:*
- [PicoVerse 2040 Features Overview](/docs/msx-picoverse-2040-features.md)
- [MSX PicoVerse 2040 PIO Strategy](/docs/msx-picoverse-2040-pio.md)
- [MSX PicoVerse 2040 MegaROMs](/docs/msx-picoverse-2040-megaroms.md)
- [MSX PicoVerse 2040 Sunrise IDE Emulation for Nextor](/docs/msx-picoverse-2040-sunrise-nextor.md)
- [MSX PicoVerse 2040 Mapper Implementation (Sunrise + Nextor)](/docs/msx-picoverse-2040-mapper.md)
- [MSX PicoVerse 2040 USB FDD](/docs/msx-picoverse-2040-msxusbfdd.md)
- [MSX PicoVerse 2040 USB Keyboard](/docs/msx-picoverse-2040-keyboard.md)
- [MSX PicoVerse 2040 USB Joystick](/docs/msx-picoverse-2040-joystick.md)
- [MSX PicoVerse 2040 MSX-MIDI](/docs/msx-picoverse-2040-msx-midi.md)
- [MSX PicoVerse 2040 MIDI-PAC](/docs/msx-picoverse-2040-midipac.md)

*PicoVerse 2350 Reference — Architecture, Storage & System:*
- [PicoVerse 2350 Features Overview](/docs/msx-picoverse-2350-features.md)
- [MSX PicoVerse 2350 PIO Strategy](/docs/msx-picoverse-2350-pio.md)
- [MSX PicoVerse 2350 Sunrise IDE Emulation for Nextor](/docs/msx-picoverse-2350-sunrise-nextor.md)
- [MSX PicoVerse 2350 DSK Disk Image Support](/docs/msx-picoverse-2350-dsk-support.md)
- [MSX PicoVerse 2350 USB FDD](/docs/msx-picoverse-2350-msxusbfdd.md)
- [MSX PicoVerse 2350 MegaRAM Implementation](/docs/msx-picoverse-2350-megaram.md)
- [MSX PicoVerse 2350 Yamanooto Implementation](/docs/msx-picoverse-2350-yamanooto.md)
- [MSX PicoVerse 2350 Carnivore2 Implementation](/docs/msx-picoverse-2350-carnivore2.md)
- [MSX PicoVerse 2350 WiFi Support](/docs/msx-picoverse-2350-wifi.md)
- [MSX PicoVerse 2350 50/60Hz VDP Frequency Implementation](/docs/msx-picoverse-2350-50-60hz.md)
- [MSX PicoVerse 2350 CPU Speed Implementation](/docs/msx-picoverse-2350-cpu-speed.md)

*PicoVerse 2350 Reference — Sound & Audio Emulation:*
- [MSX PicoVerse 2350 SCC Emulation](/docs/msx-picoverse-2350-scc.md)
- [MSX PicoVerse 2350 Dual PSG Implementation](/docs/msx-picoverse-2350-dualpsg.md)
- [MSX PicoVerse 2350 MSX-MUSIC/FM-PAC Implementation](/docs/msx-picoverse-2350-fmpac.md)
- [MSX PicoVerse 2350 OPL4 / MoonSound Implementation](/docs/msx-picoverse-2350-opl4.md)
- [MSX PicoVerse 2350 MSX-AUDIO / Y8950 Implementation](/docs/msx-picoverse-2350-msx-audio.md)
- [MSX PicoVerse 2350 WAVEGAME Protocol and Support](/docs/msx-picoverse-2350-wavegame.md)

## Hardware Variants

### PicoVerse 2040 Cartridge

| Prototype PCB (front) | Prototype PCB (back) |
|---------|---------|
|  |  | 

- Based on RP2040 boards exposing 30 GPIO pins (not compatible with stock Raspberry Pi Pico pinout).
- Up to 16 MB of flash for MSX ROMs with support for Plain16/32 (`PLA-16`/`PLA-32`), Planar48/64 (`PLN-48`/`PLN-64`), Konami SCC, Konami, ASCII8/16/16X, NEO-8, NEO-16, and Manbow2 (`MANBW2`) mappers.
- USB-C port doubles as a bridge for Nextor mass storage via Sunrise IDE emulation (`loadrom.exe -s`).
- Sunrise IDE + 192KB memory mapper mode provides both Nextor disk access and expanded RAM (`loadrom.exe -m`).
- Standalone USB keyboard firmware — use a standard USB keyboard as the MSX keyboard via the cartridge slot (`loadrom.exe -k`). Not compatible with FPGA-based MSX systems or MSX computers with an integrated PPI (e.g. T9769 MSX-ENGINE).
- Standalone MSX-MIDI firmware — use a USB-MIDI cable as a standard MSX-MIDI interface for MIDI players and sequencers (`loadrom.exe -i`).
- Standalone MIDI-PAC firmware — passively listen to the MSX PSG and convert music and effects to USB MIDI for an external synth or sound module (`loadrom.exe -p`).
- Standalone USB joystick firmware — use a standard USB gamepad as an MSX joystick via the cartridge slot (`loadrom.exe -j`). Supports Xbox One, Xbox Series X|S, and generic USB HID gamepads, with up to 2 gamepads mapped to MSX joystick ports 1 and 2.  Not compatible with FPGA-based MSX systems or MSX computers with an integrated PSG (e.g. T9769 MSX-ENGINE).
- Standalone USB Floppy Drive (FDD) and `.DSK` Disk Image firmware (`msxusbfdd.exe`) — use a real USB floppy drive (UFI/CBI/CB/Bulk-Only, **must be connected through an externally powered USB hub — never connect a USB FDD directly to the cartridge USB-C port, as it can damage the cartridge**) or mount `.DSK` disk images from a FAT12/FAT16/FAT32 USB flash drive with an on-screen boot menu and `CALL USB*` BASIC commands.

#### Bill of Materials

Interactive BOM available at [PicoVerse 2040 BOM](https://htmlpreview.github.io/?https://raw.githubusercontent.com/cristianoag/msx-picoverse-public/refs/heads/main/2040/hardware/MSX_PicoVerse_2040_1.3_bom.html)

| Reference | Description | Quantity | Link |
| --- | --- | --- | --- |
| U1 | RP2040 Dev Board 30 GPIO pins exposed | 1 | [AliExpress](https://s.click.aliexpress.com/e/_c2un4bmn) |
| C1 | 0603 0.1 µF Ceramic Capacitor | 1 | [AliExpress](https://s.click.aliexpress.com/e/_c2w5e36V) |
| C2 | 0603 10 µF Ceramic Capacitor | 1 | [AliExpress](https://s.click.aliexpress.com/e/_c2w5e36V)|
| R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13| 0603 10 kΩ Resistor | 12 | [AliExpress](https://s.click.aliexpress.com/e/_c3XBv4od)|
| R1 | 0603 2 KΩ Resistor | 1 | [AliExpress](https://s.click.aliexpress.com/e/_c3XBv4od)|
| D1 | 1N5819 SOD-123 Diode | 1 | [AliExpress](https://s.click.aliexpress.com/e/_c4WEKCuz) |
| Q1, Q2, Q3, Q4, Q5 | BSS138 SOT-23 Transistor | 5 | [AliExpress](https://s.click.aliexpress.com/e/_c3IHdO5t)|

### PicoVerse 2350 Cartridge

| Prototype PCB (front) | Prototype PCB (back) |
|---------|---------|
|  |  |

- Targets RP2350 boards exposing all 48 GPIO pins (not compatible with standard Pico 2 boards).
- Adds microSD storage, ESP8266 WiFi header, and I2S audio expansion alongside 16 MB flash space.
- Extra RAM (PSRAM) now backs the 1MB mapper modes and the Carnivore2-compatible RAM loader, with room for additional advanced firmware features.
- Explorer firmware can load ROMs from flash, optional embedded Sunrise Nextor SYSTEM entries, and microSD, cycle FAT16/FAT32/exFAT microSD browsing partitions with `P`, delete selected SD files or flash entries after confirmation with `D`, copy microSD ROMs into flash with `F`, rename ROMs, `.DSK` images and flash entries with `R`, play MP3/WAV files from microSD, browse File Hunter over ESP-01 WiFi, save downloaded File Hunter ROMs and `.DSK` disk images to the microSD root, search local title lists, select native or external SCC/SCC+, Dual PSG, MSX-MUSIC, or YM2151/SFG audio profiles per ROM where supported, and optionally mirror primary PSG audio through the cartridge DAC.
- USB-C port doubles as a bridge for Nextor mass storage via Sunrise IDE emulation (`-s2`).
- microSD card slot provides Nextor mass storage via Sunrise IDE emulation (`-s1`) when using FAT16 partitions up to 4 GB.
- Sunrise IDE + 1MB PSRAM memory mapper mode provides both Nextor disk access and expanded RAM (`-m1` for microSD, `-m2` for USB).
- Sunrise IDE + 1MB mapper + 1MB MegaRAM mode provides Nextor disk access, standard mapper RAM, and a separate writable MegaRAM cartridge surface (`-r1` for microSD, `-r2` for USB).
- Carnivore2-compatible RAM-mode loading lets `SROM.COM /D15` upload ROMs into the 1MB PSRAM mapper (`-c1` for microSD, `-c2` for USB).
- Standalone USB Floppy Drive (FDD) and `.DSK` Disk Image firmware (`msxusbfdd.exe`) — use a real USB floppy drive (UFI/CBI/CB/Bulk-Only, **must be connected through an externally powered USB hub — never connect a USB FDD directly to the cartridge USB-C port, as it can damage the cartridge**) or mount `.DSK` disk images from a FAT12/FAT16/FAT32 USB flash drive with an on-screen boot menu and `CALL USB*` BASIC commands.
- Yamanooto flash-cartridge emulation (`yamanooto.exe`) reproduces the  Yamanooto: a Konami-SCC compatible 8 MB flash cartridge with SCC/SCC+, a secondary (dual) PSG on ports `0x10`/`0x11`, a primary PSG mirror (`0xA0`/`0xA1`), and MSX-MUSIC/FM-PAC via an expanded subslot. All engines are always available and the firmware selects SCC, FM, or pure PSG on the fly, so a single image can hold a mix of SCC, FM, and PSG games.
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
## KiCad design 2350/hardware/MSX_PicoVerse_2350_1.4/MSX_PicoVerse_2350_1.4.kicad_pcb

File 2350/hardware/MSX_PicoVerse_2350_1.4/README.md (part):

# MSX PicoVerse 2350 — rev 1.4 (ESLAB derivative)

A derivative hardware revision of **The Retro Hacker's MSX PicoVerse 2350**, re-laid out in
KiCad 10 as a 4-layer board with a full source project (schematic, PCB, footprints, 3D models,
gerbers, BOM and JLCPCB fabrication data).

> **Original design:** [cristianoag/msx-picoverse-public](https://github.com/cristianoag/msx-picoverse-public) — The Retro Hacker
> **This revision:** ESLAB (Cona), 2026
> **License:** CC BY-NC-SA 4.0, same as the original

---

## Status

**rev 1.3 was built and tested on real hardware — a Panasonic MSX2, an FS-A1ST Turbo R and an
OCM. The problems found there were fixed, and the result is rev 1.4 — the design published
here.** Hardware compatibility with the original is maintained: the existing PicoVerse 2350
firmware (`explorer.pio`, `loadrom.pio`, `multirom.pio`) runs unmodified, and no firmware change
is needed for this board.

| Function | Status |
|---|---|
| MSX cartridge bus / ROM emulation | ✅ |
| microSD storage (Sunrise IDE / Nextor) | ✅ |
| USB mass storage (Sunrise IDE / Nextor) | ✅ |
| USB-C firmware upload (BOOTSEL) | ✅ |
| I2S audio out (UDA1334A) | ✅ |
| PSG / SCC / MSX-MUSIC / YM2151 / MP3 | ✅ |
| ESP-01 WiFi | ✅ — **module firmware update required, see below** |

**Fabrication data is complete and ready to order.** Gerbers, drill files, the JLCPCB placement
file (CPL) and the assembly BOM are all generated and cross-checked against the board file —
upload them as they are. See [Ordering](#ordering).

### ESP-01 needs a firmware update

The ESP-01 / ESP-01S modules sold today ship with **factory AT-command firmware**, which this
cartridge cannot talk to. Depending on which module you buy you will have to reflash it with the
**ESP8266 UNAPI firmware** before WiFi works.

- Protocol: single-character binary, **not** `AT+...`
- Baud rate: **859372**, not 115200
- Firmware: [ducasp/ESP8266-UNAPI-Firmware](https://github.com/ducasp/ESP8266-UNAPI-Firmware)
- Flash map: `fw.bin` @ `0x00000`, `certs.bin` @ `0xBB000` → **1 MB flash minimum** (ESP-01S)
- 512 KB ESP-01 modules cannot be used

Full bring-up procedure, boot strapping table, Flash Download Tool settings and diagnostics are
in [`doc/ESP01_BRINGUP.md`](doc/ESP01_BRINGUP.md).

---

## Board

| | |
|---|---|
| Dimensions | 101.15 × 66.05 mm |
| Layers | 4 (F.Cu / In1.Cu / In2.Cu / B.Cu) |
| Thickness | 1.6 mm, stackup JLC04161H-3313 |
| Surface finish | ENIG (required — gold fingers) |
| Gold fingers | J11, 25 + 25, bevelled edge |
| Parts | 104 total — 97 placed, 4 DNP, 3 board features |
| Bottom-side parts | none |

### Top

### Bottom

### Main blocks

| Ref | Part | Function |
|---|---|---|
| U1 | Waveshare Core2350B | RP2350B module, 8 MB PSRAM |
| U2 | Adafruit UDA1334A breakout | I2S stereo DAC, 3.5 mm jack overhanging the left edge |
| J2 | ESP-01 / ESP-01S socket | WiFi (see note above) |
| J4 | microSD socket | Nextor storage / ROM library |
| J5 | USB-C 16P | firmware upload **and** USB mass-storage host |
| J11 | MSX cartridge edge | 50-pin gold fingers |
| J3 | SWD header | DNP, right-angle only |
| S1 | A06-B6-1 | side-actuated BOOTSEL button |
| IC1 | AP63200WU-7 | 5 V → 3.3 V buck |
| Q1 / Q2 | DMMT5401 + SSM3J332R | ideal-diode ORing, MSX +5 V ↔ USB VBUS |

---

## How this differs from the original v1.2

The published v1.2 is a **2-layer** board (its gerber set contains only `F_Cu` and `B_Cu`) of
100.07 × 67.66 mm with **13 BOM line items** — essentially the two modules, the connectors, one
1N5819 and a handful of pull-ups. This revision is a 4-layer redraw with **39 line items /
104 parts**, and the additions fall into two groups.

### Mechanical — laid out to a moulded cartridge shell

The original provides 3D-printable shells (`2350/case/*.stl`). This revision was instead laid out
against the 2D drawing of a **commercially available plastic injection-moulded MSX cartridge
shell**, and every mechanical decision follows from it:

| | |
|---|---|
| Board outline | cut to the shell's internal profile with a deliberately tight fit — file the edge if needed rather than leave a gap, because part of the board is exposed outside the shell |
| PAD01 / PAD02 | Ø4.3 mm NPTH, positioned on the shell's screw bosses taken from the case drawing |
| S1 BOOTSEL | **side-actuated** SMD switch (A06-B6-1), actuator protruding 0.5 mm past the board outline to meet the shell's button hole. v1.2 uses a top-actuated TL3301; a top-actuated part cannot reach a side button |
| U2 3.5 mm jack | overhangs the left board edge by 3.13 mm for the shell's audio cutout |
| U2 mounting | component-side down on a 6 mm standoff, on the top side — the jack has to exit through the shell's left wall |
| J3 | right-angle header only — a vertical header hits the shell |
| U1 / U2 / J2 | no female sockets, and the header plastic spacers must be removed; socket height prevents the shell from closing |
| Finish | ENIG with bevelled gold fingers — HASL plates the fingers in tin and wears the slot contacts |

The case drawing was aligned to the board in KiCad's `User.Eco1` layer during layout.
Measured shell dimensions are recorded in [`doc/case_measured_params.md`](doc/case_measured_params.md).

### Electrical — a real power and protection section

| Added | Why |
|---|---|
| **IC1 AP63200WU-7 buck** + L1 / C10 / C11 | dedicated 5 V → 3.3 V supply instead of drawing 3V3 from the Core2350B module's own regulator |
| **Q1 DMMT5401 + Q2 SSM3J332R ideal-diode OR** | clean changeover between MSX +5 V and USB VBUS, with reverse blocking toward the MSX. v1.2 has a single 1N5819 |
| **Series resistors on the MSX bus** | R11–R26 on A0–A15, R27–R34 on D0–D7, R35–R38 on the strobes — edge-rate control and protection on a bus that is directly exposed at the slot |
| **TVS1 SM6T6V8CA** | bidirectional TVS at the MSX +5 V entry |
| **F1 FSMD075 polyfuse** | on the USB path; in rev 1.4 it also sets the USB-host current limit |
| **R52 + C22 RC filter, R50 0 Ω GNDA bridge** | separate analog supply and single-point ground for the DAC |
| **R55 / R56 5.1 k CC pull-downs, D1 3V3 clamp** | USB-C sink termination and module 3V3 overvoltage clamp |
| **ESP-01 strapping pull-ups at 4.7 kΩ** | R8 / R9 / R10 / R39 — margin against the RP2350's internal pull-downs |

---

## Revision history

**rev 1.3** — the first ESLAB board. Built, assembled and tested on real machines (see
[Verified on hardware](#verified-on-hardware)). Everything worked except **USB mass storage**,
which never enumerated.

**rev 1.4** — fixes what rev 1.3 got wrong, and is the design published here.

| Fixed | What it was |
|---|---|
| **USB mass storage** | rev 1.3 put a series Schottky (D2) in the VBUS path, so the USB-C connector could never source VBUS and a bus-powered flash drive never powered up. D2 is gone; MSX +5 V now reaches VBUS through F1. Confirmed working on a reworked rev 1.3 board with D2 replaced by a 0 Ω link |
| **ESP-01 power** | the USB-detect / power-select circuit (SW1, Q3, Q4, R40, C12) was removed. The ESP-01 now runs from +3V3 whenever the board is powered |
| **U2 in the board file** | rev 1.3's file placed U2 on B.Cu with a 3D model whose components were on the wrong face. Neither matched the board that was actually built. The file now matches: F.Cu, rotated 180°, component-side down. The 3D model is generated from the board file itself (`tools/make_uda_model.py`) so it cannot drift again |
| **Silkscreen** | SWD labels moved next to J3; the obsolete `USB POWER` / `INT POWER` labels removed |

The rev 1.4 PCB has not been fabricated yet — the verification above was done on the reworked
rev 1.3 board, which is electrically identical in the ways that matter.

---

## Verified on hardware

The rev 1.3 board was run on four machines. The original MSX2 drives the bus with 5 V TTL,
the Turbo R has the tightest bus timing, and the OCM is an FPGA implementation with different
drive characteristics.

| Machine | |
|---|---|
| Panasonic MSX2 | two different models |
| **Panasonic FS-A1ST** (MSX Turbo R) | R800, tightest bus timing of the four |
| **OCM** (one-chip MSX) | FPGA implementation |

All functions were exercised on these: WiFi, USB mass storage, microSD, DAC audio and the
cartridge bus itself.

*File-Hunter Browser listing 428 ROMs over WiFi — the ESP-01 link working end to end.*

Parts:
C1: 1nF; C0603
C2, C18, C19, C23: 10uF/16V; C0603
C3, C4, C8, C13, C17, C20, C21, C25, C28: 0.1uF; C0603
C5, C29: 1uF/16V; C0603
C6, C7: 10uF/16V; C0805
C9: 100pF; C0603
C10, C11, C14, C15: 22uF/16V; C0805
C16: 100uF/16V; C3225; not fitted
C22: 10uF/16V; C1206
C24, C26: 4.7nF; C0603
C27: 4.7uF/16V; C0603
D1: B5819WS; SOD323
F1: FSMD075-1812; 1812L
FB1: 120; L0805
IC1: AP63200WU-7; TSOT26
J2: ESP-01; ESP-01-
J3: SWD; PinHeader_1x03_P2.54mm_Horizontal; not fitted
J4: Micro_SD_Card; Conn_uSDcard
J5: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J11: MSX Cartridge Edge Fingers; MSX_Cartridge_Edge_Fingers
L1: SPH5030-100M; SPH5030
PAD01, PAD02: TH_PADM3; MountingHole_4.3mm_M4
Q1: DMMT5401; SOT23-6L
Q2: SSM3J332R; SOT23
R1, R2: 47k; R0603
R3, R5, R35, R36, R37, R38: 330R; R0603
R4: 4K7; R0603
R6: 196kF; R0603
R7: 62kF; R0603
R8, R9, R10, R39: 4.7k; R0603
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R53, R54: 1K; R0603
R27, R28, R29, R30, R31, R32, R33, R34: 470R; R0603
R41, R42, R45, R46, R47, R48, R49, R51, R59: 10K; R0603
R43, R44: 10k; R0603; not fitted
R50: 0R; R0603
R52: 10; R0805
R55, R56: 5.1K; R0603
R57: 2.2k; R0603
R58: 2K2; R0603
S1: NW3-A06-B6; SW_A06-B6-1
TVS1: SM6T6V8CA; DO214SMB_TVS
U1: Core2350B; Core2350
U2: UDA1334MOD

Connections:
+3V3: C13.1, C14.1, C15.1, C16.1, C19.1, C21.1, D1.1 (C), FB1.2, J2.8 (VCC), J4.4 (VDD), R8.2, R9.1, R10.1, R39.1, R41.2, R45.1, R46.1, R47.1, R48.1, R49.1, R51.1
+5V: C1.1, C4.1, C5.1, C6.1, C7.1, C17.1, C18.1, C23.2, C25.1, F1.2, IC1.2 (EN), IC1.3 (VIN), Q1.6 (E1), Q2.2 (SOURCE), R52.2, U1.34 (VBUS)
/+3V3_BUCK: C9.1, C10.1, C11.1, FB1.1, L1.2, R6.1
/+5V_DAC: C20.1, C22.1, R52.1, U2.1 (VIN)
/+5V_MSX: C2.2, C3.2, J11.45 (+5V), J11.47 (+5V), Q1.5 (E2), Q2.3 (DRAIN), TVS1.2 (K)
/A0_M: J11.28 (A0), R11.1
/A1_M: J11.27 (A1), R12.1
/A2_M: J11.30 (A2), R13.1
/A3_M: J11.29 (A3), R14.1
/A4_M: J11.32 (A4), R15.1
/A5_M: J11.31 (A5), R16.1
/A6_M: J11.22 (A6), R17.1
/A7_M: J11.21 (A7), R18.1
/A8_M: J11.24 (A8), R19.1
/A9_M: J11.17 (A9), R20.2
/A10_M: J11.20 (A10), R21.1
/A11_M: J11.19 (A11), R22.1
/A12_M: J11.23 (A12), R23.1
/A13_M: J11.26 (A13), R24.1
/A14_M: J11.25 (A14), R25.1
/A15_M: J11.18 (A15), R26.1
/BUSDIR: J11.10 (~BUSDIR), U1.53 (GP37)
/CART_SW: J11.44 (SW1), J11.46 (SW2)
/D0_M: J11.34 (D0), R27.1
/D1_M: J11.33 (D1), R28.1
/D2_M: J11.36 (D2), R29.1
/D3_M: J11.35 (D3), R30.1
/D4_M: J11.38 (D4), R31.1
/D5_M: J11.37 (D5), R32.1
/D6_M: J11.40 (D6), R33.1
/D7_M: J11.39 (D7), R34.1
/ESP01_UART_RX: J2.7 (RXD), U1.22 (GP38)
/ESP01_UART_TX: J2.2 (TXD), U1.54 (GP39)
/ESP_EN: J2.4 (CH_PD), R8.1, U1.25 (GP44)
/ESP_IO0: J2.5 (GPIO0), R39.2, U1.56 (GP43)
/ESP_RST: J2.6 (~RST), R9.2, U1.24 (GP42)
/GP41_SPARE: R42.2, U1.55 (GP41)
/I2S_BCLK_PIN: U1.17 (GP30), U2.6 (BCLK)
/I2S_DATA_PIN: U1.16 (GP29), U2.5 (DIN)
/I2S_MUTE: U1.19 (GP32), U2.12 (MUTE)
/I2S_WSEL_PIN: U1.50 (GP31), U2.4 (WSEL)
/INT: J11.8 (~INT), U1.23 (GP40)
/IORQ_M: J11.11 (~IORQ), R37.1
/MSX_CLK: R5.1, U1.57 (GP46)
/MSX_M1: R3.2, U1.26 (GP45)
/ORING_GATE: C1.2, Q1.1 (C1), Q2.1 (GATE), R1.2
/RD_M: J11.14 (~RD), R35.1
/RESET: R4.2, R41.1, U1.32 (RUN)
/SD_DAT1: J4.8 (DAT1), R45.2
/SD_DAT2: J4.1 (DAT2), R51.2
/SLTSL_M: J11.4 (~SLTSL), R38.1
/SOUNDIN: C29.2, J11.49 (SOUNDIN)
/SPI_CD: J4.2 (DAT3/CD), R49.2, U1.51 (GP33)
/SPI_MISO: J4.7 (DAT0), R46.2, U1.21 (GP36)
/SPI_MOSI: J4.3 (CMD), R48.2, U1.52 (GP35)
/SPI_SCK: J4.5 (CLK), R47.2, U1.20 (GP34)
/SWCLK: J3.2, U1.60 (SWCLK)
/SWDIO: J3.1, U1.58 (SWDIO)
/USB+: J5.A6 (D+), J5.B6 (D+), U1.31 (U+/DP)
/USB-: J5.A7 (D-), J5.B7 (D-), U1.30 (U-/DM)
/VBUS: C27.2, C28.2, F1.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS)
/WAIT: J11.7 (~WAIT), U1.49 (GP28)
/WR_M: J11.13 (~WR), R36.1
GND: C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C25.2, C27.1, C28.1, IC1.4 (GND), J2.1 (GND), J3.3, J4.6 (VSS), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.SH (SHIELD), J11.41 (GND), J11.43 (GND), R1.1, R2.1, R7.2, R42.1, R43.1, R44.1, R50.1, R55.1, R56.2, S1.1, S1.3, S1.4, TVS1.1 (A), U1.0 (GND), U1.9 (GND), U1.18 (GND), U1.27 (GND), U1.59 (GND), U1.62 (GND), U2.3 (GND), U2.10 (SCLK), U2.11 (SF1), U2.13 (SF0)
GNDA: C24.2, C26.2, R50.2, R59.1, U2.8 (AGND)
unnamed: C24.1, R54.1, R57.1
unnamed: C26.1, R53.1, R58.2
unnamed: C29.1, R57.2, R58.1, R59.2
unnamed: D1.2 (A), U1.63 (3V3)
unnamed: C8.2, IC1.6 (BST)
unnamed: C9.2, IC1.1 (FB), R6.2, R7.1
unnamed: C8.1, IC1.5 (SW), L1.1
unnamed: J2.3 (GPIO2), R10.2
unnamed: J5.A5 (CC1), R55.2
unnamed: J5.B5 (CC2), R56.1
unnamed: J11.42 (CLOCK), R5.2
unnamed: J11.9 (~M1), R3.1
unnamed: J11.15 (~RESET), R4.1
unnamed: Q1.2 (B1), Q1.3 (B2), Q1.4 (C2), R2.2
unnamed: S1.2, U1.29 (BOOTSEL)
unnamed: R11.2, U1.35 (GP00)
unnamed: R12.2, U1.36 (GP01)
unnamed: R13.2, U1.1 (GP02)
unnamed: R14.2, U1.37 (GP03)
unnamed: R15.2, U1.2 (GP04)
unnamed: R16.2, U1.38 (GP05)
unnamed: R17.2, U1.3 (GP06)
unnamed: R18.2, U1.39 (GP07)
unnamed: R19.2, U1.4 (GP08)
unnamed: R20.1, U1.40 (GP09)
unnamed: R21.2, U1.5 (GP10)
unnamed: R22.2, U1.41 (GP11)
unnamed: R23.2, U1.6 (GP12)
unnamed: R24.2, U1.42 (GP13)
unnamed: R25.2, U1.7 (GP14)
unnamed: R26.2, U1.8 (GP15)
unnamed: R27.2, U1.43 (GP16)
unnamed: R28.2, U1.10 (GP17)
unnamed: R29.2, U1.44 (GP18)
unnamed: R30.2, U1.11 (GP19)
unnamed: R31.2, U1.45 (GP20)
unnamed: R32.2, U1.12 (GP21)
unnamed: R33.2, U1.46 (GP22)
unnamed: R34.2, U1.13 (GP23)
unnamed: R35.2, U1.47 (GP24)
unnamed: R36.2, U1.14 (GP25)
unnamed: R37.2, U1.48 (GP26)
unnamed: R38.2, U1.15 (GP27)
unnamed: R44.2, U2.15 (DEEM)
unnamed: R53.2, U2.7 (LOUT)
unnamed: R43.2, U2.14 (PLL)
unnamed: R54.2, U2.9 (ROUT)

Notes on the sheet:
오디오 출력 : U2 L/R -> R53·R54(1K) -> C26·C24(4.7nF) -> R58·R57(2K2) 합산 -> R59(10K) -> C29(1uF) -> SOUNDIN GNDA 는 R50(0R) 한 점에서만 GND 와 연결. In1.Cu GND 플레인은 자르지 말 것.
(3) ESP-01 전원을 SW1 로 [상시] / [USB 연결 시에만] 선택. (4) DAC 전원 RC 필터(R52+C22), GNDA 분리, 4층 전환.
아이디얼 다이오드 (MSX 전원 우선) Q1 DMMT5401 정합쌍 + Q2 P-FET, 강하 20~50 mV 슬롯 전압이 처지면 USB 가 자동으로 분담
USB-C 디바이스 포트 CC1/CC2 = 5.1K 풀다운 F1 PTC 홀드 0.75 A
MSX 카트리지 슬롯 (50핀 엣지, 기판 두께 1.58 mm)
MSX PicoVerse 2350 rev 1.3 원설계 : The Retro Hacker
rev 1.2 를 공개 Gerber X2 / IBOM 에서 복원 후 개정.
USB D+/D- : 90 Ω 차동 F.Cu(L1) 전용, 기준면 In1.Cu(L2) GND 선폭 0.29 / 간격 0.203 mm (JLC04161H-3313) 비아·스터브 금지, 길이차 ±5 mm, 총 60 mm 이하
설계 주기 1. 기판 : 4층, JLC04161H-3313, 완성 두께 1.58 mm. 엣지 커넥터 물림 규격이므로 두께 변경 금지. 2. 내층 In1.Cu 는 통짜 GND. USB 쌍과 고속 신호 아래에서 절대 자르지 말 것. 3. GNDA 는 U2(DAC) 출력부만 감싸는 F.Cu 로컬 폴리곤. R50(0R) 한 점으로만 GND 와 연결. 4. 골드핑거 영역 전 층 구리 제거(키아웃) 완료. 표면처리 ENIG 권장, 45도 베벨. 5. 넷클래스 : Power 0.6 / Analog 0.3 / USB 0.29 차동 / 기타 0.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
MSX 버스 직렬 보호 저항 - RP2350B 는 IOVDD+0.6 V 에서 클램프하며 저항이 주입 전류를 제한한다. 주소 A0~A15 = 1K (입력 전용) / 데이터 D0~D7 = 470R (양방향, 로우 레벨 확보) 스트로브 /RD /WR /IORQ /SLTSL, /M1, CLOCK = 330R (타이밍 우선) / /RESET = 4K7
펌웨어 : rev 1.2 의 PIO 엔진을 수정 없이 사용 GPIO drive strength 2 mA 권장 (엣지 완만 -> EMI 유리)
ESP-01 전원 선택 (SW1 / SK-12D02) 1번 위치 : 시스템 전원으로 상시 동작 3번 위치 : USB 연결 시에만 동작 - Q3(DTC114E)가 VBUS 검출 -> Q4 ON WiFi TX 350 mA 는 슬롯 예산을 넘으므로 USB 병용 권장
(2) 전원 재구성 : MSX +5V 는 아이디얼 다이오드(Q1/Q2), USB VBUS 는 D2 + F1(PTC). +3V3 은 IC1 AP63200 벅.
U1 : Waveshare Core2350B 모듈 (RP2350B, PSRAM 8MB) 모듈 3V3(pad63) 은 자체 LDO 출력이므로 벅 출력과 분리 D1 이 버스 주입 전류를 +3V3 으로 흘려보낸다
USB-C 디바이스 포트 CC1/CC2 = 5.1K 풀다운 D2 : 역류 차단 + VBUS 검출 기준점
변경 (1) 74LVC245A / 74LVC07A 버스 버퍼 전량 삭제 -> 직렬 저항 방식. DIR 제어 GPIO 불필요, rev 1.2 펌웨어 그대로 사용.
전원 계통 +5V_MSX -> Q2 아이디얼 다이오드 -> +5V VBUS -> D2 -> F1(PTC 0.75A) -> +5V +5V -> IC1 벅 -> +3V3 (FB1 경유) 전압 차에 따라 두 경로가 분담
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
Board: 4 copper layers, 101.2 x 66.1 mm, 104 parts (0 on the bottom side), 112 nets.

File 2350/hardware/MSX_PicoVerse_2350_1.4/MSX_PicoVerse_2350_1.4_BOM.csv:

# MSX PicoVerse 2350  rev 1.4  BOM   (2026-09-23)
# 원설계 The Retro Hacker / rev 1.3~1.4 개정 ESLAB
# ★ 표시 항목은 대체품 사용 시 동작에 영향이 있습니다
"No","수량","레퍼런스","값","패키지","구분","실장","기능","비고"
"1","9","C3, C4, C8, C13, C17, C20, C21, C25, C28","0.1uF","0603","커패시터","실장","+5V_MSX 디커플링 · ESP 디커플링 · IC1 부트스트랩 (BST-SW) 외",""
"2","1","C9","100pF","0603","커패시터","실장","IC1 피드포워드 (R6 병렬)",""
"3","1","C16","100uF/16V","1210","커패시터","DNP","ESP 예비 벌크","DNP — WiFi 동작이 불안정할 때만 실장"
"4","4","C2, C18, C19, C23","10uF/16V","0603","커패시터","실장","+5V_MSX 벌크",""
"5","2","C6, C7","10uF/16V","0805","커패시터","실장","",""
"6","1","C22","10uF/16V","1206","커패시터","실장","U2 DAC 전원 필터","★ 10µF 16V 1206 고정 — DC 바이어스 디레이팅 때문에 0603/6.3V 대체 금지"
"7","1","C1","1nF","0603","커패시터","실장","Q2 게이트-소스 (오링 턴오프 완충)",""
"8","2","C5, C29","1uF/16V","0603","커패시터","실장","오디오 출력 커플링 → SOUNDIN",""
"9","4","C10, C11, C14, C15","22uF/16V","0805","커패시터","실장","ESP 벌크 · 벅 출력 벌크",""
"10","2","C24, C26","4.7nF","0603","커패시터","실장","오디오 L 필터 · 오디오 R 필터",""
"11","1","C27","4.7uF/16V","0603","커패시터","실장","VBUS 바이패스",""
"12","1","D1","B5819WS","SOD-323","다이오드","실장","","모듈 3V3 과전압 클램프 (U1 pad63 → +3V3)"
"13","1","F1","FSMD075-1812","1812","퓨즈","실장","","★★ rev1.4에서 역할이 바뀌었다. D2 삭제로 F1이 +5V ↔ VBUS 를 양방향으로 잇는 유일한 소자다. MSX +5V가 F1을 통해 J5 VBUS로 나가 USB 메모리에 급전된다. 홀드 0.75A / 트립 1.5A — 이 값이 곧 USB 호스트 전류 제한이다. 0Ω 점퍼로 대체 금지"
"14","1","FB1","120R","0805","페라이트비드","실장","","★ 120Ω@100MHz / 정격 1A 이상 / DCR 0.05Ω 이하. ESP TX 350mA 통과 — 일반 200mA 비드 사용 금지"
"15","1","IC1","AP63200WU-7","TSOT-26","IC","실장","","★ TSOT-26. 오디오에 주기적 잡음 발생 시 AP63201WU-7(강제 PWM)로 핀 호환 교체 가능"
"16","1","J2","ESP-01","2x04 2.54mm 헤더","커넥터","실장","","ESP-01 / ESP8266 모듈 접속부. rev1.4에서 전원이 +3V3 상시 급전으로 단순화됨 (SW1/Q4 삭제) / ★조립: 핀헤더 소켓(암) 사용 금지 - 케이스 간섭. 핀헤더 플라스틱 지지대 제거 후 기판에 밀착"
"17","1","J4","Micro_SD_Card","microSD 소켓","커넥터","실장","","microSD 소켓"
"18","1","J3","SWD","1x03 2.54mm 라이트앵글","커넥터","DNP","","DNP — SWD 3핀 헤더. 기본 미실장, 펌웨어 디버깅이 필요할 때만 실장. 실장 시 반드시 라이트 앵글(수평) 사용 (수직형은 케이스 간섭)"
"19","1","J5","USB_C_Receptacle_USB2.0_16P","USB-C 16P","커넥터","실장","","★★ USB-C 리셉터클 16P. rev1.4에서 USB 메모리(매스스토리지) 호스트 포트를 겸한다. CC1/CC2는 Rd 5.1k 고정이라 규격상 싱크 배선이며, VBUS 급전은 F1 경유 상시다. MSX에 꽂은 상태로 PC에 연결하지 말 것 (역급전)"
"20","1","L1","SPH5030-100M","SPH5030 5x3mm","인덕터","실장","","★ 10µH / Isat 1A 이상 / DCR 100mΩ 이하"
"21","1","Q1","DMMT5401","SOT-23-6","트랜지스터","실장","","★ 정합 PNP 쌍 — 개별 PNP 2개로 대체 금지 (정합도가 오링 동작의 핵심)"
"22","1","Q2","SSM3J332R","SOT-23","트랜지스터","실장","","오링 P-FET (MSX +5V 우선)"
"23","1","R50","0R","0603","저항","실장","","★ 0Ω — GNDA ↔ GND 단일점 브리지. 반드시 실장 (미실장 시 아날로그 GND 부유)"
"24","1","R52","10R","0805","저항","실장","","★ 저항 10Ω 0805 — 비드 아님. U2 DAC 전원 RC 필터 (C22와 조합, fc 2.3kHz)"
"25","9","R41, R42, R45, R46, R47, R48, R49, R51, R59","10k","0603","저항","실장","GP41_SPARE 풀다운 · RESET 풀업 · microSD 풀업 외",""
"26","2","R43, R44","10k","0603","저항","DNP","","DNP — U2 모듈에 PLL 풀다운이 없을 때만 실장 / DNP — U2 모듈에 DEEM 풀다운이 없을 때만 실장"
"27","1","R6","196k 1%","0603","저항","실장","","★ 1% — 벅 출력 3.33V 결정. 5% 사용 금지"
"28","18","R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R53, R54","1k","0603","저항","실장","MSX 버스 직렬 보호 — 주소 A0~A15 · 오디오 L 직렬 · 오디오 R 직렬",""
"29","2","R57, R58","2.2k","0603","저항","실장","오디오 합산",""
"30","6","R3, R5, R35, R36, R37, R38","330R","0603","저항","실장","MSX /M1 직렬 · MSX CLOCK 직렬 · MSX 버스 직렬 보호 — 스트로브",""
"31","5","R4, R8, R9, R10, R39","4.7k","0603","저항","실장","ESP /RST 풀업 · ESP CH_PD 풀업 · ESP GPIO0 풀업 외",""
"32","8","R27, R28, R29, R30, R31, R32, R33, R34","470R","0603","저항","실장","MSX 버스 직렬 보호 — 데이터 D0~D7 (양방향, 로우레벨 확보)",""
"33","2","R1, R2","47k","0603","저항","실장","Q1 베이스 바이어스 · Q2 게이트 풀다운",""
"34","2","R55, R56","5.1k","0603","저항","실장","USB-C CC1 풀다운 · USB-C CC2 풀다운",""
"35","1","R7","62k 1%","0603","저항","실장","","★ 1% — 벅 출력 3.33V 결정. 5% 사용 금지"
"36","1","S1","NW3-A06-B6","SMD 측면푸시 4.55x2.3x1.8","스위치","실장","","BOOTSEL 버튼 / ★ 측면 조작형 SMD (A06-B6-1). 상면 푸시형(PTS645 등)과 호환 안 됨 — 단자 피치 3.4mm, 위치결정 보스 Ø0.6 x 2 (기판 Ø0.75 비도금 홀). DC12V 50mA / 접촉저항 30mΩ 이하 / 스트로크 0.25mm / 작동력 220~250gf / 수명 10만회"
"37","1","TVS1","SM6T6V8CA","DO-214AA (SMB)","TVS","실장","","양방향 TVS, +5V_MSX 진입점. VBUS 계통에는 TVS가 없다 (D2 삭제로 보호 소자 없음)"
"38","1","U1","Core2350B","모듈 2x32 2.54mm","모듈","실장","","Waveshare Core2350B (RP2350B, PSRAM 8MB) / ★조립: 핀헤더 소켓(암) 사용 금지 - 케이스 간섭. 핀헤더 플라스틱 지지대 제거 후 기판에 밀착 납땜"
"39","1","U2","UDA1334MOD","모듈 9+6핀 2.54mm","모듈","실장","","UDA1334A I2S DAC 모듈 (Adafruit 호환) / ★ 기판 앞면(F면) 실장 (rev1.3 파일이 뒷면으로 잡고 있던 것을 실물에 맞춰 정정) / ★★부품면(UDA1334ATS·47µF 2개·3.5mm 잭)이 기판을 향하도록 엎어서 꽂는다 — 핀헤더는 모듈의 부품면에서 나온다 / ★★스탠드오프 6.0mm 필요 (47µF 캔 5.4mm + 여유). 핀헤더 플라스틱 지지대 2.54mm 로는 부족하므로 긴핀 헤더(핀 길이 11mm 이상) 또는 스페이서 사용. 전고 7.6mm / ★3.5mm 잭이 기판 좌측 외곽선 밖으로 3.13mm 돌출, 기판면 기준 Z 1.0~6.0mm — 케이스 타공 위치 확인 / ★핀헤더 소켓(암) 사용 금지"

"[rev 1.3 → 1.4 변경점]"
"D2 (B5819WS)","삭제 — USB VBUS 역류 차단 다이오드. 이것 때문에 MSX 구동 시 J5 VBUS가 0V였고 USB 메모리가 인식되지 않았다. 제거하여 +5V가 F1을 통해 VBUS로 급전된다"
"SW1 (SK-12D02)","삭제 — ESP 전원 선택 스위치. ESP-01은 +3V3 상시 급전으로 단순화"
"Q3 (DTC114EUA)","삭제 — VBUS 검출. D2 제거로 VBUS가 상시 활성이 되어 검출 의미가 없어짐"
"Q4 (SSM3J332R)","삭제 — ESP 전원 스위치 P-FET"
"R40 (10k)","삭제 — Q4 게이트 풀업"
"C12 (0.1µF)","삭제 — Q4 게이트 소프트스타트"
"F1 (FSMD075)","역할 변경 — +5V ↔ VBUS 양방향 경로이자 USB 호스트 전류 제한 소자"
"U2 (UDA1334MOD)","기판 뒷면(B.Cu) → 앞면(F.Cu) 정정. 설계 변경이 아니라 rev1.3 파일이 실물과 달랐던 것을 맞춘 것. 3.5mm 잭이 기판 좌측 외곽선 밖으로 3.13mm 돌출하도록 180도 회전 배치"

"[기판 일체 — 구매 불필요]"
"J11","MSX 카트리지 엣지 핑거 — 기판 일체, 구매 불필요"
"PAD01","M4 마운팅홀 (Ø4.3 비도금) — 기판 일체"
"PAD02","M4 마운팅홀 (Ø4.3 비도금) — 기판 일체"

"[조립 주의사항]"
"U1 / U2 / J2","핀헤더 소켓(암) 사용 금지 — 소켓 높이 때문에 케이스를 닫을 수 없습니다"
"U1 / J2","핀헤더의 플라스틱 지지대(스페이서)를 제거한 뒤 조립할 것. 모듈이 기판에 밀착되어야 합니다"
"U2","★★U2 는 반대입니다 — 밀착시키지 마십시오. 부품면을 아래로 엎어 꽂으므로 6.0mm 스탠드오프가 필요합니다 (47µF 캔 5.4mm + 여유 0.6mm)"
"U2","rev1.4에서 기판 앞면(F면)으로 정정되었습니다 — rev1.3 파일이 뒷면으로 잡고 있었을 뿐 실물은 앞면이었습니다. 이 보드에 뒷면 부품은 없습니다"
"U2","모듈의 부품면(UDA1334ATS · 47µF 2개 · 3.5mm 잭)이 2350 기판을 향합니다. 핀헤더는 모듈의 부품면에서 나와 기판을 관통합니다. 위로 보이는 것은 모듈의 민면입니다"
"U2","기판면 기준 Z 배치 — 47µF 캔 0.6~6.0 / 3.5mm 잭 1.0~6.0 / 모듈 PCB 6.0~7.6. 전고 7.6mm. 상판 셸까지 10.35mm 이므로 여유 2.75mm"
"U2","핀헤더 길이 확인 — 기판 아래 3.2mm + 스탠드오프 6.0mm + 모듈 1.6mm = 최소 10.8mm 관통 길이가 필요합니다"
"U2","3.5mm 오디오 잭이 기판 좌측 외곽선 밖으로 3.13mm 돌출합니다. 잭 중심 높이는 기판면에서 약 3.5mm — 케이스 타공 위치를 확인하십시오"
"U2","조립 방향 주의 — 반대로 꽂으면 손상됩니다. F.Silkscreen 의 1번 핀 표시 확인"
"J2","rev1.4부터 ESP-01 전원은 +3V3 상시입니다. 전원 선택 스위치(SW1)가 없습니다"
"J5","rev1.4부터 USB 메모리 호스트 포트를 겸합니다. VBUS는 F1을 통해 MSX +5V에서 상시 공급됩니다"
"J5","★★ MSX에 카트리지를 꽂은 상태에서 PC에 USB 케이블을 연결하지 마십시오 — D2가 없어 MSX 5V가 PC VBUS로 역류합니다. 펌웨어 업로드는 카트리지를 빼고 하십시오"
"J3","DNP(기본 미실장). 실장할 경우 라이트 앵글(수평) 헤더만 사용 — 수직형은 케이스에 간섭합니다"
"S1","측면 푸시형. 액추에이터가 기판 외곽선보다 0.5mm 바깥으로 나옵니다 — 케이스 버튼 타공/플런저 위치 확인"
"S1","위치결정 보스 Ø0.6 두 개가 기판의 Ø0.75 비도금 홀에 완전히 안착된 것을 확인한 뒤 납땜할 것"
"J11","골드핑거 — 표면처리 ENIG 권장, 45도 베벨"
"J3 / R43 / R44 / C16","DNP. 기본 미실장"

## Commit log (part)

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2025-12-20 Update hardware files for PicoVerse 2040 v1.3 release. Update README with BOM links.
2025-12-21 Update for the multirom manual
2025-12-25 Review Nextor options
2025-12-26 Source code publishing for 2040
2025-12-26 2350 Source Code
2025-12-26 Loadrom update
2025-12-26 README.md
2025-12-26 Translation
2025-12-26 Labels and README.md adjustments
2025-12-26 Binaries with the right flasg and README.md adjustments
2025-12-26 fix name of the multirom image
2025-12-26 Updates on documentation
2025-12-28 WAIT assert adjusts while not using cache. Copyright notes on README

Notices in the files:
README.md:
License, Copyright notes & Usage:
All hardware and firmware binaries in this repository are released under the Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International license. Personal builds and community tinkering are encouraged, but **commercial use or resale requires explicit authorization from the author**.
bios.h** is used on all MSX menus and was adapted from http://www.konamiman.com/msx/msx2th/th-ap.txt by Danilo Angelo, 2020. The original file is licensed under CC0 1.0 Universal (public domain). The adapted bios.h fil
